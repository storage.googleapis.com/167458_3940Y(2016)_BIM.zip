Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-03-25T15:50:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 25 15:50:00 2019 * Host: DESKTOP-23GQEAI * Database: C:\Users\vladb\AppData\Local\Temp\{D7D54D89-EECA-4EFB-8559-1A803005DFC3}\ifc * Database version: 5507 * Database creation date: Mon Mar 25 15:49:58 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 25 15:49:59 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 25 15:49:59 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 3940Y Bath and shower faucet, 3940Y(2016):3940Y Bath and shower faucet:320249
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - NominalDepth: 178.5 mm; NominalHeight: 122 mm; NominalWidth: 220 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 3940Y(2016); ConvergoRefNr: 0087-1803-0070-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 20/03/2019
Type - Green Building Properties(Type) - Approval ABP: PA-IX 29208/IDB; Approval KIWA SE Type Approval: 1446; Customs Code: 84818011; EAN Number: 6414150078156; URL ABP: http://static.oras.com/ABP/3940Y; URL KIWA SE Type Approval: http://static.oras.com/SETypeApproval/3940Y
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/3940Y; Catalog Drawing URL: http://static.oras.com/catdrw/3940Y; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/3940Y; FDV Document URL: http://www.oras.com/datasheet/3940Y/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/3940Y; Group: Bath and shower faucets; Long Marketing: Bath and shower faucet with eccentric unions, 150cc and cover plates are included. There are also in-built limitation options for water temperature and maximum flow-rate.; Manufacturer: Oras; Market: INT;POL;RUS;EST;LTU;LVA;UKR; Model: 3940Y Bath and shower faucet; Name_en: 3940Y Bath and shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 210 x 185 x 160; Package Weight: 2.120 kg; Product Code: 3940Y; Product Datasheet: http://www.oras.com/datasheet/3940Y/en; Product Family: Oras Saga; Product Image URL: http://static.oras.com/image/3940Y; Product URL: http://static.oras.com/3940Y; Type Name: 3940Y Bath and shower faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection: Covered eccentric unions; Diverter: Pull diverter; Flow: Limitation option for maximum flow rate; Flow Rate At 300kPa: 0.0116538 m3/s; Installation and Maintenance: http://static.oras.com/manual/3940Y; Installation Type: Wall-mounted; Installation Width: CC150 mm; Max. Hot Water Supply: 80 kg/K/s3; Noise Class: II (ISO 3822) Oras lab.; Pressure Loss With Flow 02ls: 165000 Pa; Pressure Loss With Flow 03ls: 300000 Pa; Spare Parts: http://static.oras.com/sp/3940Y; Spout Type: Fixed spout; Temperature: Temperature limiter
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 3940Y(2016); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 3940Y; Name: 3940Y Bath and shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 220x180x120 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 3940Y; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 3940Y Bath and shower faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0898921 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00480348 m3
Identity Data - Mark: 6
Mechanical - System Classification: Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 3940Y(2016): 3940Y Bath and shower faucet; Family and Type: 3940Y(2016): 3940Y Bath and shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 3940Y(2016): 3940Y Bath and shower faucet; Type Id: 3940Y(2016): 3940Y Bath and shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
